FILESEXTRAPATHS_prepend := "${THISDIR}/swupdate-rpi-client:"
