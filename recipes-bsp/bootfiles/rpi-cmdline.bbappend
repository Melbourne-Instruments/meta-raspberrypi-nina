CMDLINE_append = " consoleblank=0 vt.global_cursor_default=0 isolcpus=3"
